# Keil uVision project 点亮LED.uvproj, settings and files
target LED (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 点亮LED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BSP
  group USER
    ./: STARTUP.A51 mian.c
  group BSP
    ./BSP/: GPIO.c delay.c
    ../../BSP/: Nixietube.c
